require recipes-core/images/core-image-sato.bb

IMAGE_INSTALL += "rust-spray"
